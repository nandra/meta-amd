SUMMARY = "Lib64 setup "
LICENSE = "MIT"

do_install() {
}

ALLOW_EMPTY:${PN} = "1"


